# Repository jvierine/prnboard (continued)

## KiCad design hardware/prnboard.kicad_pcb (continued)

Schematic: interlock_1.kicad_sch, PRNboard / Interlock 1

Parts:
C49: 4u7; C49; MPN SELECT_IN_BOM
C50: 1u; C50; MPN SELECT_IN_BOM
C51: 100n; C51; MPN SELECT_IN_BOM
R29: 1M; R29; MPN SELECT_IN_BOM
R30: 100k; R30; MPN SELECT_IN_BOM
R31: 10k; R31; MPN SELECT_IN_BOM
R32: 10k; R32; MPN SELECT_IN_BOM
R33: 10k; R33; MPN SELECT_IN_BOM
R34: 10k; R34; MPN SELECT_IN_BOM
U14: 74HC123D; U14; MPN 74HC123D,653
U15: 74LVC2G08; U15; MPN 74LVC2G08DC,125
U16: SN74LVC1G08DBVR; U16; MPN SN74LVC1G08DBVR

Connections:
3V3D: C51.1, R29.1, R30.1, U14.16 (VCC), U15.8 (VCC), U16.5 (VCC); also elsewhere on the board
ARMED: U15.3, U16.2 (B)
CLOCK_ALIVE: U15.7, U16.1 (A)
GND: C51.2, R31.2, R32.2, R33.2, R34.2, U14.1 (A), U14.8 (GND), U14.9 (A), U15.4 (GND), U16.3 (GND); also elsewhere on the board
HEARTBEAT: R33.1, U14.10 (B); also elsewhere on the board
PPS: U14.2 (B); also elsewhere on the board
PPS_ALIVE: U14.13 (Q), U15.1; also elsewhere on the board
PPS_C: C49.1, U14.14 (Cext)
PPS_RC: C49.2, R29.2, U14.15 (RCext)
QUALIFIED: R32.1, U15.5; also elsewhere on the board
RUN: U14.3 (Clr), U14.11 (Clr); also elsewhere on the board
TX_ENABLE: R34.1, U16.4 (Y); also elsewhere on the board
TX_REQUEST: R31.1, U15.6; also elsewhere on the board
WD_ALIVE: U14.5 (Q), U15.2; also elsewhere on the board
WD_C: C50.1, U14.6 (Cext)
WD_RC: C50.2, R30.2, U14.7 (RCext)

Schematic: interlock_2.kicad_sch, PRNboard / Interlock 2

Parts:
C52: 100n; C52; MPN SELECT_IN_BOM
C53: 100n; C53; MPN SELECT_IN_BOM
R35: 10k; R35; MPN SELECT_IN_BOM

Connections:
3V3D: C52.1, C53.1; also elsewhere on the board
GND: C52.2, C53.2, R35.2; also elsewhere on the board
PA_OK: R35.1; also elsewhere on the board

Schematic: expansion.kicad_sch, PRNboard / Expansion

Parts:
J4: SWD; J4; MPN SWD
J5: ESP PROGRAM; J5; MPN ESP PROGRAM
J6: GNSS EXPANSION; J6; MPN GNSS EXPANSION
J7: PA CONTROL; J7; MPN PA CONTROL
J8: DIGITAL IO; J8; MPN DIGITAL IO

Connections:
3V3D: J4.2, J5.2, J8.2; also elsewhere on the board
3V3G: J6.2; also elsewhere on the board
ADC_PA_FWD: J7.4; also elsewhere on the board
ADC_PA_REV: J7.5; also elsewhere on the board
GND: J4.1, J5.1, J6.1, J7.1, J7.6, J8.1; also elsewhere on the board
GNSS_RX: J6.3; also elsewhere on the board
GNSS_TX: J6.4; also elsewhere on the board
GPIO0: J8.3; also elsewhere on the board
GPIO1: J8.4; also elsewhere on the board
PA_OK: J7.3; also elsewhere on the board
PPS: J6.5; also elsewhere on the board
REF10: J6.6; also elsewhere on the board
RUN: J4.5; also elsewhere on the board
SWCLK: J4.3; also elsewhere on the board
SWDIO: J4.4; also elsewhere on the board
TX_ENABLE: J7.2; also elsewhere on the board
WIFI_BOOT: J5.6; also elsewhere on the board
WIFI_EN: J5.5; also elsewhere on the board
WIFI_RX: J5.3; also elsewhere on the board
WIFI_TX: J5.4; also elsewhere on the board

Board: 4 copper layers, 144 parts (0 on the bottom side), 93 nets, no tracks yet.

Other parts of the board:
H44, H481, H914, H9181: MountingHole_3.2mm_M3
